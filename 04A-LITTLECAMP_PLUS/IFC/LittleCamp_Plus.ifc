Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement [Architecture]
File name: 0001
Time: 2023-05-23T15:31:29
Author: Iperboole srl, info@iperboole.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.50.27 - Exporter 21.2.1.0 - Alternate UI 21.2.1.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 23 15:31:29 2023 * Host: DESKTOP-EF0D6F5 * Database: C:\Users\FRANCE~1\AppData\Local\Temp\9cfa61fd-fc0a-459d-8ab3-0ce2c6f543f3\86e234a7-dd96-4bd2-b864-08a6e7983a0d\ifc * Database version: 5507 * Database creation date: Tue May 23 15:31:28 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 23 15:31:28 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 23 15:31:28 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Refineair-Mockup

# IfcSite, Default
RefLatitude: 41, 47, 59, 999999; RefLongitude: 12, 35, 59, 999999; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Maggio 2023; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Refineair; Nome del progetto: Refineair-Mockup; Numero del progetto: 0001
Dati identità - Autore: Iperboole srl

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Maggio 2023; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Refineair; Nome del progetto: Refineair-Mockup; Numero del progetto: 0001
Dati identità - Autore: Iperboole srl

# IfcBuildingStorey: Livello:Estremità 8 mm, Livello 1
LongName: Livello 1; Elevation: 0 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Altro - Categoria: Livelli; Famiglia: Livello: Estremità 8 mm; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: Livello: Estremità 8 mm; Tipo: Livello: Estremità 8 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 mm
Vincoli - Quota altimetrica: 0 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Estremità 8 mm
Grafica(Type) - Colore: 0; Modello di linea: Centro (2); Simbolo: M_Estremità del livello - Cerchio: M_Estremità del livello - Cerchio; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcEnergyConversionDevice: AM-LittleCamp_Plus:AM-LittleCamp_Plus, AM-LittleCamp_Plus:AM-LittleCamp_Plus:1042242
In: Livello 1
Type - Material: Plastica_Nera
Type - Altro - Categoria: Attrezzatura meccanica; Nome famiglia: AM-LittleCamp_Plus
Type - Dati identità - Nome del tipo: AM-LittleCamp_Plus; Numero OmniClass: 23.75.50.17.17; Titolo OmniClass: Electronic Air Cleaners; URL: https://www.refineair.it/prodotti/
Type - Meccanica - Classificazione: Nessuno
Type - Vincoli - Prospetto di default: 0 mm
Material: Plastica_Nera, Acciaio_zincato, Sughero, Filtro_poliestere, Lamiera_Bianca, <Unnamed>, ABS, PVC, Lampada, Catalizzatore, Ingombro
Pset_DistributionFlowElementCommon - Reference: AM-LittleCamp_Plus; sets with these values: 2
Altro - Famiglia: AM-LittleCamp_Plus: AM-LittleCamp_Plus; Famiglia e tipo: AM-LittleCamp_Plus: AM-LittleCamp_Plus; ID tipo: AM-LittleCamp_Plus: AM-LittleCamp_Plus; Tipo: AM-LittleCamp_Plus: AM-LittleCamp_Plus
Costruzione - Peso: 8 kg; Portata: 0.05 m3/s; Potenza sonora max dB(A): 58
Dati - Certificazioni: https://www.refineair.it/certificati-e-test/certificazioni/; Certificazioni txt: https://www.refineair.it/certificati-e-test/certificazioni; LOD: F; Manuale manutenzione: https://www.refineair.it/download/; Manuale manutenzione txt: https://www.refineair.it/download/; Manuale uso: https://www.refineair.it/download/; Manuale uso txt: https://www.refineair.it/download/; TABELLA: LittleCamp_Plus
Dati identità - Codice prodotto: LC-PLUS-I; Modellato da: Iperboole srl; Nome prodotto: LITTLE CAMP PLUS PCO technology + Bipolar ionization; Prodotto da: Refineair
Dimensioni - Altezza: 90 mm; Area: 2.3216 m2; Larghezza: 380 mm; Profondita: 90 mm; Volume: 0.616381 m3
Elettrico - Fasi: 1; Frequenza: 50 Hz; IN: 0.1 A; Lampada_IN: 0.064 A; Lampada_Potenza: 9.8 W; Lampada_Tensione: 219 V; Potenza assorbita max: 42 W; Tensione corrente: 230 V
Fasi - Fase di creazione: Nuova costruzione
Meccanica - Classificazione sistema: Alimentazione,Dati
Vincoli - Host: Livello : Livello 1; Livello: Livello: Livello 1; Offset da host: 0 mm; Quota altimetrica da livello: 0 mm
Visibilità - Componenti_interne: yes; Ingombro: yes; Supporti: yes; TAGLI: yes
